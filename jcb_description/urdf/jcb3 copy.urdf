Commit message: add linux files

File: jcb_description/urdf/jcb3 copy.urdf (robot description, URDF)
Before this commit: robot jcb3, 4 links, 3 joints
Joints:
- joint Joint_1: axis 0 0 1 -> 0 1 0
- joint Joint_2: axis 0 0 1 -> 0 1 0
- joint Joint_3: axis 0 0 1 -> 0 1 0
